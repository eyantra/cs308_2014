# Keil uVision project test_freertos.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: test_freertos +hex
  AfterMake: fromelf --bin .\test_freertos.axf -o .\test_freertos.bin
  c flags: Optim=1
  c include: .;..\..\Source\include;..\Common\include;..\..\Source\portable\RVDS\ARM7_LPC21xx
  asm include: ..\..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s buzzer.c defines.h Lcd.c uartISR.s
  group freertos
    ../../Source/: tasks.c queue.c list.c
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
